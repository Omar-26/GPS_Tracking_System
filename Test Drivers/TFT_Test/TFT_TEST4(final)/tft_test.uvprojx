# Keil uVision project tft_test.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tft_test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
    ./TFT/: ST7735.c ST7735.h
    ./mcal/ssi/: ssi.c ssi.h ssi_types.h
    ./mcal/PortDriver/: port.c port.h port_types.h
    ./mcal/SysCtr/: SysCtr.c SysCtr.h SysCtr_types.h
    ./mcal/: mcu_hw.c mcu_hw.h
    ./mcal/nvic/: nvic.c nvic.h nvic_types.h
    ./mcal/dio/: dio.c dio.h dio_types.h
    ./utils/processor/: processor.c processor.h
    ./Service/Delay_ms/: Delay_ms.c Delay_ms.h
    ./config/: nvic_cfg.h nvic_lcfg.c port_cfg.h port_lcfg.c ssi_cfg.h ssi_lcfg.c SysCtr_cfg.c SysCtr_cfg.h
    ./utils/: Bit_Math.h STD_types.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.1
