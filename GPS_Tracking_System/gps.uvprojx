# Keil uVision project gps.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gps
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: BIT_MATH.h EEPROM_Interface.h EEPROM_Program.c GPIO_config.h GPIO_Interface.h GPIO_Private.h GPIO_Program.c IO.h SPI_Interface.h STD_TYPES.h tm4c123gh6pm.h UART_Config.h UART_Interface.h UART_Private.h UART_Program.c main.c fonts.c fonts.h GPS_interface.h TFT_config.h TFT_interface.h TFT_private.h iota.h Sys_Tick.h Sys_Tick.c GPS_Program.c uart_.c uart_.h FTOS.c FTOS.h iota.c
    ./mcal/ssi/: ssi.c ssi.h ssi_types.h
    ./mcal/dio/: dio.c dio.h dio_types.h
    ./mcal/nvic/: nvic.c nvic.h nvic_types.h
    ./mcal/PortDriver/: port.c port.h port_types.h
    ./mcal/SysCtr/: SysCtr.c SysCtr.h SysCtr_types.h
    ./TFT/: ST7735.c ST7735.h
    ./utils/processor/: processor.c processor.h
    ./Service/Delay_ms/: Delay_ms.c Delay_ms.h
    ./mcal/: mcu_hw.c mcu_hw.h
    ./config/: nvic_cfg.h nvic_lcfg.c port_cfg.h port_lcfg.c ssi_cfg.h ssi_lcfg.c SysCtr_cfg.c SysCtr_cfg.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.1
